# Keil uVision project EDOG-SmartHome-stm32f103c8t6-gizwist+snr8016+bh1750+uln2003+fan.uvprojx, settings and files
target SmartHome (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartLock +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Project;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\..\BSP;..\..\HARDWARE;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\..\SYSTEM;..\..\Common;..\..\..\Project-Root;..\..\SYSTEM\TIMER;..\..\Utils;..\..\Gizwits;..\..\HARDWARE\Key;..\..\HARDWARE\Led;..\..\HARDWARE\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ../: main.c stm32f10x_it.c
    ../SysApp/: AppParam.c AppSys.c
  group HARDWARE
    ../../HARDWARE/Key/: bsp_key.c
    ../../HARDWARE/dht11/: bsp_dht11.c
    ../../HARDWARE/Led/: led.c
    ../../HARDWARE/GY30/: BH1750FVI.c
    ../../HARDWARE/Relay/: bsp_relay.c
    ../../HARDWARE/SNR1806/: snr1806.c
    ../../HARDWARE/ULN2003/: uln2003.c
    ../../HARDWARE/Buzzer/: bsp_buzzer.c
    ../../HARDWARE/OLED/: oled.c
  group SYSTEM
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/usart/: usart.c
    ../../SYSTEM/TIMER/: timer.c
    ../../SYSTEM/PWM/: pwm.c
    ../../SYSTEM/ADC/: ADC.c
  group Gizwits
    ../../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../../Utils/: common.c dataPointTools.c ringbuffer.c
  group Common
    ../../Common/: user_common.c
